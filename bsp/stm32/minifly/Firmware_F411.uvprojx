# Keil uVision project Firmware_F411.uvprojx, settings and files
target Firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware_F411 +hex
  AfterMake: fromelf --bin !L -o .\BIN\Firmware_F411_V1.3.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --preinclude stm32f4xx_conf.h --diag_suppress=767
  c include: ..\..\..\CORE;..\..\..\SYSTEM\delay;..\..\..\SYSTEM\sys;..\minifly;..\..\..\CONFIG\interface;..\..\..\HARDWARE\interface;..\..\..\FreeRTOS\include;..\..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\..\USB\STM32_USB_Device_Library\Core\inc;..\..\..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\..\..\USB\STM32_USB_OTG_Driver\inc;..\..\..\USB\USB_APP\interface;..\..\..\FLIGHT\interface;..\..\..\COMMON\interface;..\..\..\COMMUNICATE\interface;..\..\..\EXP_MODULES\interface;..\..\..\VL53L1X;..\..\..\VL53L1X\vl53l1_platform;..\..\..\plat\stm32\stm32f411;..\libraries\std\STM32F4xx_STD\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c system_stm32f4xx.c
  group SYSTEM
    ../../../SYSTEM/delay/: delay.c
    ../../../SYSTEM/sys/: sys.c
  group CONFIG
    ../../../CONFIG/src/: config_param.c
    ../../../CONFIG/interface/: config.h config_param.h FreeRTOSConfig.h stm32f4xx_conf.h
  group HARDWARE
    ../../../HARDWARE/src/: ak8963.c bmp280.c module_detect.c led.c motors.c mpu6500.c nvic.c uart_syslink.c uart1.c system.c stmflash.c watchdog.c ws2812.c spl06.c vl53lxx_i2c.c vl53l0x.c vl53l1x.c
  group EXP_MODULES
    ../../../EXP_MODULES/src/: wifi_ctrl.c ledring12.c module_mgt.c optical_flow.c vl53lxx.c
  group VL53L1X
    ../../../VL53L1X/: vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
  group CORE
    ../../../CORE/: startup_stm32f411xe.s
  group DSP_LIB
    ../../../DSP_Lib/: arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mean_f32.c arm_sin_f32.c
  group FreeRTOS
    ../../../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../../../FreeRTOS/portable/MemMang/: heap_4.c
  group USB_OTG
    ../../../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../../../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../../../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_APP
    ../../../USB/USB_APP/src/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
    ../../../USB/USB_APP/interface/: usbd_cdc_vcp.h usbd_conf.h usb_conf.h
  group COMMUNICATE
    ../../../COMMUNICATE/src/: atkp.c comm.c commander.c ledseq.c console.c pm.c radiolink.c remoter_ctrl.c usblink.c
  group FLIGHT
    ../../../FLIGHT/src/: anomal_detec.c attitude_pid.c flip.c pid.c position_pid.c power_control.c sensfusion6.c sensors.c stabilizer.c state_control.c state_estimator.c
  group COMMON
    ../../../COMMON/src/: debug_assert.c freeRTOSdebug.c filter.c filter2.c maths.c
  group README
    ../../../: readme.txt
  group plat
    ../../../plat/stm32/stm32f411/: plat_interrupt.c i2c_drv.c i2cdev.c spi.c usart.c pwm.c
  group bsp_libraries
    ../libraries/std/STM32F4xx_STD/src/: misc.c stm32f4xx_adc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
